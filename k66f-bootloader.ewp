# IAR project k66f-bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MK66FN2M0xxx18 NXP MK66FN2M0xxx18
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: CPU_MK66FN2M0VLQ18
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.PreInclude: devices\MK66F18\utilities\fsl_debug_console.h
  ICCARM.CCIncludePath2: ; CMSIS\Include; devices\MK66F18; devices\MK66F18\utilities; devices\MK66F18\drivers; board
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: BOOTLOADER.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: MK66FN2M0xxx18_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM, debug)
  as the first configuration, except:
  group (top)
    ./: main.c MK66FN2M0xxx18_flash.icf partition.h
  group board
    board/: board.c board.h clock_config.c clock_config.h pin_mux.c pin_mux.h
  group CMSIS/include
    CMSIS/Include/: cmsis_compiler.h cmsis_iccarm.h core_cm4.h
  group devices
    devices/MK66F18/: fsl_device_registers.h MK66F18.h MK66F18_features.h
    devices/MK66F18/drivers/: fsl_gpio.c fsl_gpio.h
  group devices/drivers
    devices/MK66F18/drivers/: fsl_clock.c fsl_clock.h fsl_common.c fsl_common.h fsl_flash.c fsl_flash.h fsl_lpuart.c fsl_lpuart.h fsl_smc.c fsl_smc.h fsl_uart.c fsl_uart.h
  group devices/startup
    devices/MK66F18/iar/: startup_MK66F18.s
    devices/MK66F18/: system_MK66F18.c system_MK66F18.h
  group devices/utilities
    devices/MK66F18/utilities/: fsl_debug_console.c fsl_debug_console.h
  group flash
    flash/: internal_flash.c internal_flash.h
